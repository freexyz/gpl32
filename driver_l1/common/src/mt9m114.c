/*
 ******************************************************************************
 * mt9m114.c -
 *
 * Copyright (c) 2013-2015 by ZealTek Electronic Co., Ltd.
 *
 * This software is copyrighted by and is the property of ZealTek
 * Electronic Co., Ltd. All rights are reserved by ZealTek Electronic
 * Co., Ltd. This software may only be used in accordance with the
 * corresponding license agreement. Any unauthorized use, duplication,
 * distribution, or disclosure of this software is expressly forbidden.
 *
 * This Copyright notice MUST not be removed or modified without prior
 * written consent of ZealTek Electronic Co., Ltd.
 *
 * ZealTek Electronic Co., Ltd. reserves the right to modify this
 * software without notice.
 *
 * History:
 *	2013.11.05	T.C. Chiu	frist edition
 *
 ******************************************************************************
 */
#include "drv_l1_sensor.h"
#include "gplib.h"


#if (defined _DRV_L1_SENSOR) && (_DRV_L1_SENSOR == 1)
#ifdef __MT9M114_DRV_C__

/*
 * for debug
 */
#define DEBUG_MT9M114		1
#if DEBUG_MT9M114
    #define _D(x)		(x)
#else
    #define _D(x)
#endif

/*
 * definitions
 */
#define MT9M114_ID		0x90	// 0xBA

#define MT9M114_VGA		1
#define MT9M114_1024x768	0
#define MT9M114_1280x960	0
#define MT9M114_720P		0

/*
 * macros
 */
#define sccb_rd_r16d8		sccb_read_Reg16Data8
#define sccb_wr_r16d8		sccb_write_Reg16Data8

#define sccb_rd_r16d16		sccb_read_Reg16Data16
#define sccb_wr_r16d16		sccb_write_Reg16Data16

#define sccb_rd_r16d32		sccb_read_Reg16Data32
#define sccb_wr_r16d32		sccb_write_Reg16Data32


/*
 *****************************************************************************
 *
 *
 *
 *****************************************************************************
 */
static void mt9m114_host_command_x(INT16U cmd)
{
	INT16U	tmp;

	switch (cmd) {
	case 0x8001:	_D(DBG_PRINT(" HOST_COMMAND_0 = 0x%04X, apply patch\r\n", cmd));	break;
	case 0x8002:	_D(DBG_PRINT(" HOST_COMMAND_1 = 0x%04X, set state\r\n", cmd));		break;
	case 0x8004:	_D(DBG_PRINT(" HOST_COMMAND_2 = 0x%04X, refresh\r\n", cmd));		break;
	case 0x8008:	_D(DBG_PRINT(" HOST_COMMAND_3 = 0x%04X, wait for event\r\n", cmd));	break;
	default:	_D(DBG_PRINT(" unknown host command\r\n"));				break;
	}
	sccb_wr_r16d16(MT9M114_ID, 0x0080, cmd);

	_D(DBG_PRINT(" poll HOST_COMMAND"));
	while (1) {
		sccb_rd_r16d16(MT9M114_ID, 0x0080, &tmp);
		_D(DBG_PRINT(", 0x%04X", (INT16U) tmp));
		if ((tmp & 0x000F) != (cmd & 0x000F)) {
			break;
		}
		drv_msec_wait(50);
	}
	_D(DBG_PRINT("\r\n"));
}

/*
 *****************************************************************************
 * Description:	MT9M114 Initialization
 * Syntax: void mt9m114_init(
 *			  signed short nWidthH,		// Active H Width
 *			  signed short nWidthV,		// Active V Width
 *			unsigned short uFlag		// Flag Type
 *			);
 * Return: None
 *****************************************************************************
 */
void mt9m114_init(short nWidthH, short nWidthV,	unsigned short uFlag)
{
	INT16U	uCtrlReg1, uCtrlReg2;
	INT8U	inreso = 1;		//1:VGA, 0:QVGA


	_D(DBG_PRINT("\033[1;36mMT9M114 - mount\r\n\033[0m"));

	// Enable CSI clock to let sensor initialize at first
//	uCtrlReg2      = CLKOEN | CSI_RGB565 | CSI_HIGHPRI | CSI_NOSTOP | CLK_SEL48M;
	uCtrlReg2      = CLKOEN | CSI_RGB565 | CSI_HIGHPRI | CSI_NOSTOP | CLK_SEL27M;
//	R_SYSTEM_CTRL &= ~0x4000;	// (freq/1)
	R_SYSTEM_CTRL |= 0x4000;	// (freq/2)

	uCtrlReg1 = CSIEN | YUV_YUYV | CAP;	// Default CSI Control Register 1
	if (uFlag & FT_CSI_RGB1555) {		// RGB1555
		uCtrlReg2 |= CSI_RGB1555;
	}
	if (uFlag & FT_CSI_CCIR656) {		// CCIR656
		uCtrlReg1 |= CCIR656 | VADD_FALL | VRST_FALL | HRST_FALL;
		uCtrlReg2 |= D_TYPE1;
	} else {				// NOT CCIR656
		uCtrlReg1 |= VADD_RISE | VRST_FALL | HRST_RISE;
		uCtrlReg2 |= D_TYPE0;
	}
	if (uFlag & FT_CSI_YUVIN) { 		// YUVIN?
		uCtrlReg1 |= YUVIN;
	}
	if (uFlag & FT_CSI_YUVOUT) {		// YUVOUT?
		uCtrlReg1 |= YUVOUT;
	}

	// Whether compression or not?
	if ((nWidthH == 320) && (nWidthV == 240)) {
		if (inreso == 1) {
			// VGA in, QVGA out
			R_CSI_TG_HRATIO  = 0x0102;	// Scale to 1/2
			R_CSI_TG_VRATIO  = 0x0102;	// Scale to 1/2
			R_CSI_TG_HWIDTH  = nWidthH*2;	// Horizontal frame width
			R_CSI_TG_VHEIGHT = nWidthV*2;	// Vertical frame width
		}
	} else {
		R_CSI_TG_HRATIO  = 0;
		R_CSI_TG_VRATIO  = 0;
	}

	R_CSI_TG_VL0START = 0x0000;		// Sensor field 0 vertical latch start register.
	R_CSI_TG_VL1START = 0x0000;		//*P_Sensor_TG_V_L1Start = 0x0000;
	R_CSI_TG_HSTART   = 0x0000;		// Sensor horizontal start register.

	R_CSI_TG_CTRL0 = 0;			//reset control0
	R_CSI_TG_CTRL1 = CSI_NOSTOP | CLKOEN;	//enable CSI CLKO
	drv_msec_wait(100);

	// CMOS Sensor Initialization Start...
	sccb_init();
	sccb_delay(200);


	// reset
	_D(DBG_PRINT(" soft reset\r\n"));
	sccb_wr_r16d16(MT9M114_ID, 0x301A, 0x0234);	// RESET_REGISTER
	drv_msec_wait(300);

	//
	sccb_wr_r16d16(MT9M114_ID, 0x316A, 0x8270);	// RESERVED_CORE_316A
	sccb_wr_r16d16(MT9M114_ID, 0x316C, 0x8270);	// RESERVED_CORE_316C
	sccb_wr_r16d16(MT9M114_ID, 0x3ED0, 0x2305);	// RESERVED_CORE_3ED0
	sccb_wr_r16d16(MT9M114_ID, 0x3ED2, 0x77CF);	// RESERVED_CORE_3ED2
	sccb_wr_r16d16(MT9M114_ID, 0x316E, 0x8202);	// RESERVED_CORE_316E
	sccb_wr_r16d16(MT9M114_ID, 0x3180, 0x87FF);	// RESERVED_CORE_3180
	sccb_wr_r16d16(MT9M114_ID, 0x30D4, 0x6080);	// RESERVED_CORE_30D4
	sccb_wr_r16d16(MT9M114_ID, 0xA802, 0x0008);	// RESERVED_AE_TRACK_02
	sccb_wr_r16d16(MT9M114_ID, 0x3E14, 0xFF39);	// RESERVED_CORE_3E14
	sccb_wr_r16d16(MT9M114_ID, 0xC892, 0x0267);	// CAM_AWB_CCM_L_0
	sccb_wr_r16d16(MT9M114_ID, 0xC894, 0xFF1A);	// CAM_AWB_CCM_L_1
	sccb_wr_r16d16(MT9M114_ID, 0xC896, 0xFFB3);	// CAM_AWB_CCM_L_2
	sccb_wr_r16d16(MT9M114_ID, 0xC898, 0xFF80);	// CAM_AWB_CCM_L_3
	sccb_wr_r16d16(MT9M114_ID, 0xC89A, 0x0166);	// CAM_AWB_CCM_L_4
	sccb_wr_r16d16(MT9M114_ID, 0xC89C, 0x0003);	// CAM_AWB_CCM_L_5
	sccb_wr_r16d16(MT9M114_ID, 0xC89E, 0xFF9A);	// CAM_AWB_CCM_L_6
	sccb_wr_r16d16(MT9M114_ID, 0xC8A0, 0xFEB4);	// CAM_AWB_CCM_L_7
	sccb_wr_r16d16(MT9M114_ID, 0xC8A2, 0x024D);	// CAM_AWB_CCM_L_8
	sccb_wr_r16d16(MT9M114_ID, 0xC8A4, 0x01BF);	// CAM_AWB_CCM_M_0
	sccb_wr_r16d16(MT9M114_ID, 0xC8A6, 0xFF01);	// CAM_AWB_CCM_M_1
	sccb_wr_r16d16(MT9M114_ID, 0xC8A8, 0xFFF3);	// CAM_AWB_CCM_M_2
	sccb_wr_r16d16(MT9M114_ID, 0xC8AA, 0xFF75);	// CAM_AWB_CCM_M_3
	sccb_wr_r16d16(MT9M114_ID, 0xC8AC, 0x0198);	// CAM_AWB_CCM_M_4
	sccb_wr_r16d16(MT9M114_ID, 0xC8AE, 0xFFFD);	// CAM_AWB_CCM_M_5
	sccb_wr_r16d16(MT9M114_ID, 0xC8B0, 0xFF9A);	// CAM_AWB_CCM_M_6
	sccb_wr_r16d16(MT9M114_ID, 0xC8B2, 0xFEE7);	// CAM_AWB_CCM_M_7
	sccb_wr_r16d16(MT9M114_ID, 0xC8B4, 0x02A8);	// CAM_AWB_CCM_M_8
	sccb_wr_r16d16(MT9M114_ID, 0xC8B6, 0x01D9);	// CAM_AWB_CCM_R_0
	sccb_wr_r16d16(MT9M114_ID, 0xC8B8, 0xFF26);	// CAM_AWB_CCM_R_1
	sccb_wr_r16d16(MT9M114_ID, 0xC8BA, 0xFFF3);	// CAM_AWB_CCM_R_2
	sccb_wr_r16d16(MT9M114_ID, 0xC8BC, 0xFFB3);	// CAM_AWB_CCM_R_3
	sccb_wr_r16d16(MT9M114_ID, 0xC8BE, 0x0132);	// CAM_AWB_CCM_R_4
	sccb_wr_r16d16(MT9M114_ID, 0xC8C0, 0xFFE8);	// CAM_AWB_CCM_R_5
	sccb_wr_r16d16(MT9M114_ID, 0xC8C2, 0xFFDA);	// CAM_AWB_CCM_R_6
	sccb_wr_r16d16(MT9M114_ID, 0xC8C4, 0xFECD);	// CAM_AWB_CCM_R_7
	sccb_wr_r16d16(MT9M114_ID, 0xC8C6, 0x02C2);	// CAM_AWB_CCM_R_8
	sccb_wr_r16d16(MT9M114_ID, 0xC8C8, 0x0075);	// CAM_AWB_CCM_L_RG_GAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC8CA, 0x011C);	// CAM_AWB_CCM_L_BG_GAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC8CC, 0x009A);	// CAM_AWB_CCM_M_RG_GAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC8CE, 0x0105);	// CAM_AWB_CCM_M_BG_GAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC8D0, 0x00A4);	// CAM_AWB_CCM_R_RG_GAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC8D2, 0x00AC);	// CAM_AWB_CCM_R_BG_GAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC8D4, 0x0A8C);	// CAM_AWB_CCM_L_CTEMP
	sccb_wr_r16d16(MT9M114_ID, 0xC8D6, 0x0F0A);	// CAM_AWB_CCM_M_CTEMP
	sccb_wr_r16d16(MT9M114_ID, 0xC8D8, 0x1964);	// CAM_AWB_CCM_R_CTEMP
	sccb_wr_r16d16(MT9M114_ID, 0xC914, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC916, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC918, 0x04FF);	// CAM_STAT_AWB_CLIP_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91A, 0x02CF);	// CAM_STAT_AWB_CLIP_WINDOW_YEND
	sccb_wr_r16d16(MT9M114_ID, 0xC904, 0x0033);	// CAM_AWB_AWB_XSHIFT_PRE_ADJ
	sccb_wr_r16d16(MT9M114_ID, 0xC906, 0x0040);	// CAM_AWB_AWB_YSHIFT_PRE_ADJ
	sccb_wr_r16d8(MT9M114_ID,  0xC8F2, 0x03);	// CAM_AWB_AWB_XSCALE
	sccb_wr_r16d8(MT9M114_ID,  0xC8F3, 0x02);	// CAM_AWB_AWB_YSCALE
	sccb_wr_r16d16(MT9M114_ID, 0xC906, 0x003C);	// CAM_AWB_AWB_YSHIFT_PRE_ADJ
	sccb_wr_r16d16(MT9M114_ID, 0xC8F4, 0x0000);	// CAM_AWB_AWB_WEIGHTS_0
	sccb_wr_r16d16(MT9M114_ID, 0xC8F6, 0x0000);	// CAM_AWB_AWB_WEIGHTS_1
	sccb_wr_r16d16(MT9M114_ID, 0xC8F8, 0x0000);	// CAM_AWB_AWB_WEIGHTS_2
	sccb_wr_r16d16(MT9M114_ID, 0xC8FA, 0xE724);	// CAM_AWB_AWB_WEIGHTS_3
	sccb_wr_r16d16(MT9M114_ID, 0xC8FC, 0x1583);	// CAM_AWB_AWB_WEIGHTS_4
	sccb_wr_r16d16(MT9M114_ID, 0xC8FE, 0x2045);	// CAM_AWB_AWB_WEIGHTS_5
	sccb_wr_r16d16(MT9M114_ID, 0xC900, 0x03FF);	// CAM_AWB_AWB_WEIGHTS_6
	sccb_wr_r16d16(MT9M114_ID, 0xC902, 0x007C);	// CAM_AWB_AWB_WEIGHTS_7
	sccb_wr_r16d8(MT9M114_ID,  0xC90C, 0x80);	// CAM_AWB_K_R_L
	sccb_wr_r16d8(MT9M114_ID,  0xC90D, 0x80);	// CAM_AWB_K_G_L
	sccb_wr_r16d8(MT9M114_ID,  0xC90E, 0x80);	// CAM_AWB_K_B_L
	sccb_wr_r16d8(MT9M114_ID,  0xC90F, 0x88);	// CAM_AWB_K_R_R
	sccb_wr_r16d8(MT9M114_ID,  0xC910, 0x80);	// CAM_AWB_K_G_R
	sccb_wr_r16d8(MT9M114_ID,  0xC911, 0x80);	// CAM_AWB_K_B_R
	sccb_wr_r16d16(MT9M114_ID, 0xC926, 0x0020);	// CAM_LL_START_BRIGHTNESS
	sccb_wr_r16d16(MT9M114_ID, 0xC928, 0x009A);	// CAM_LL_STOP_BRIGHTNESS
	sccb_wr_r16d16(MT9M114_ID, 0xC946, 0x0070);	// CAM_LL_START_GAIN_METRIC
	sccb_wr_r16d16(MT9M114_ID, 0xC948, 0x00F3);	// CAM_LL_STOP_GAIN_METRIC
	sccb_wr_r16d16(MT9M114_ID, 0xC952, 0x0020);	// CAM_LL_START_TARGET_LUMA_BM
	sccb_wr_r16d16(MT9M114_ID, 0xC954, 0x009A);	// CAM_LL_STOP_TARGET_LUMA_BM
	sccb_wr_r16d8(MT9M114_ID,  0xC92A, 0x70);	// CAM_LL_START_SATURATION
	sccb_wr_r16d8(MT9M114_ID,  0xC92B, 0x18);	// CAM_LL_END_SATURATION
	sccb_wr_r16d8(MT9M114_ID,  0xC92C, 0x10);	// CAM_LL_START_DESATURATION
	sccb_wr_r16d8(MT9M114_ID,  0xC92D, 0xF0);	// CAM_LL_END_DESATURATION
	sccb_wr_r16d8(MT9M114_ID,  0xC92E, 0x30);	// CAM_LL_START_DEMOSAIC
	sccb_wr_r16d8(MT9M114_ID,  0xC92F, 0x06);	// CAM_LL_START_AP_GAIN
	sccb_wr_r16d8(MT9M114_ID,  0xC930, 0x06);	// CAM_LL_START_AP_THRESH
	sccb_wr_r16d8(MT9M114_ID,  0xC931, 0x60);	// CAM_LL_STOP_DEMOSAIC
	sccb_wr_r16d8(MT9M114_ID,  0xC932, 0x01);	// CAM_LL_STOP_AP_GAIN
	sccb_wr_r16d8(MT9M114_ID,  0xC933, 0x0C);	// CAM_LL_STOP_AP_THRESH
	sccb_wr_r16d8(MT9M114_ID,  0xC934, 0x3C);	// CAM_LL_START_NR_RED
	sccb_wr_r16d8(MT9M114_ID,  0xC935, 0x3C);	// CAM_LL_START_NR_GREEN
	sccb_wr_r16d8(MT9M114_ID,  0xC936, 0x3C);	// CAM_LL_START_NR_BLUE
	sccb_wr_r16d8(MT9M114_ID,  0xC937, 0x0F);	// CAM_LL_START_NR_THRESH
	sccb_wr_r16d8(MT9M114_ID,  0xC938, 0x64);	// CAM_LL_STOP_NR_RED
	sccb_wr_r16d8(MT9M114_ID,  0xC939, 0x64);	// CAM_LL_STOP_NR_GREEN
	sccb_wr_r16d8(MT9M114_ID,  0xC93A, 0x64);	// CAM_LL_STOP_NR_BLUE
	sccb_wr_r16d8(MT9M114_ID,  0xC93B, 0x32);	// CAM_LL_STOP_NR_THRESH
	sccb_wr_r16d16(MT9M114_ID, 0xC93C, 0x0020);	// CAM_LL_START_CONTRAST_BM
	sccb_wr_r16d16(MT9M114_ID, 0xC93E, 0x009A);	// CAM_LL_STOP_CONTRAST_BM
	sccb_wr_r16d16(MT9M114_ID, 0xC940, 0x00DC);	// CAM_LL_GAMMA
	sccb_wr_r16d8(MT9M114_ID,  0xC942, 0x38);	// CAM_LL_START_CONTRAST_GRADIENT
	sccb_wr_r16d8(MT9M114_ID,  0xC943, 0x30);	// CAM_LL_STOP_CONTRAST_GRADIENT
	sccb_wr_r16d8(MT9M114_ID,  0xC944, 0x50);	// CAM_LL_START_CONTRAST_LUMA_PERCENTAGE
	sccb_wr_r16d8(MT9M114_ID,  0xC945, 0x19);	// CAM_LL_STOP_CONTRAST_LUMA_PERCENTAGE
	sccb_wr_r16d16(MT9M114_ID, 0xC94A, 0x0230);	// CAM_LL_START_FADE_TO_BLACK_LUMA
	sccb_wr_r16d16(MT9M114_ID, 0xC94C, 0x0010);	// CAM_LL_STOP_FADE_TO_BLACK_LUMA
	sccb_wr_r16d16(MT9M114_ID, 0xC94E, 0x01CD);	// CAM_LL_CLUSTER_DC_TH_BM
	sccb_wr_r16d8(MT9M114_ID,  0xC950, 0x05);	// CAM_LL_CLUSTER_DC_GATE_PERCENTAGE
	sccb_wr_r16d8(MT9M114_ID,  0xC951, 0x40);	// CAM_LL_SUMMING_SENSITIVITY_FACTOR
	sccb_wr_r16d8(MT9M114_ID,  0xA407, 0x00);	// AE_RULE_AE_WEIGHT_TABLE_0_0
	sccb_wr_r16d8(MT9M114_ID,  0xA40B, 0x00);	// AE_RULE_AE_WEIGHT_TABLE_0_4
	sccb_wr_r16d8(MT9M114_ID,  0xA41B, 0x00);	// AE_RULE_AE_WEIGHT_TABLE_4_0
	sccb_wr_r16d8(MT9M114_ID,  0xA41F, 0x00);	// AE_RULE_AE_WEIGHT_TABLE_4_4
	sccb_wr_r16d8(MT9M114_ID,  0xC87A, 0x4B);	// CAM_AET_TARGET_AVERAGE_LUMA
	sccb_wr_r16d8(MT9M114_ID,  0xC87B, 0x20);	// CAM_AET_TARGET_AVERAGE_LUMA_DARK
	sccb_wr_r16d8(MT9M114_ID,  0xC878, 0x0E);	// CAM_AET_AEMODE
	sccb_wr_r16d16(MT9M114_ID, 0xC890, 0x0100);	// CAM_AET_TARGET_GAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC882, 0x0184);	// CAM_AET_AE_MAX_VIRT_DGAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC886, 0x0400);	// CAM_AET_AE_MAX_VIRT_AGAIN
	sccb_wr_r16d16(MT9M114_ID, 0xC87C, 0x0050);	// CAM_AET_BLACK_CLIPPING_TARGET
	sccb_wr_r16d8(MT9M114_ID,  0xB42A, 0x05);	// CCM_DELTA_GAIN
	sccb_wr_r16d16(MT9M114_ID, 0x098E, 0xA808);	// LOGICAL_ADDRESS_ACCESS
	sccb_wr_r16d8(MT9M114_ID,  0xA808, 0x02);	// AE_TRACK_GATE_PERCENTAGE
	sccb_wr_r16d8(MT9M114_ID,  0xA80A, 0x08);	// AE_TRACK_AE_TRACKING_DAMPENING_SPEED
	sccb_wr_r16d8(MT9M114_ID,  0xA80B, 0x08);	// AE_TRACK_AE_DAMPENING_SPEED
	sccb_wr_r16d16(MT9M114_ID, 0x098E, 0x0000);	// LOGICAL_ADDRESS_ACCESS
//	sccb_wr_r16d16(MT9M114_ID, 0xC86C, 0x0C10);	// CAM_OUTPUT_FORMAT: Cb-Y-Cr-Y
	sccb_wr_r16d16(MT9M114_ID, 0xC86C, 0x0C11);	// CAM_OUTPUT_FORMAT: Cr-Y-Cb-Y
//	sccb_wr_r16d16(MT9M114_ID, 0xC86C, 0x0C12);	// CAM_OUTPUT_FORMAT: Y-Cb-Y-Cr
//	sccb_wr_r16d16(MT9M114_ID, 0xC86C, 0x0C13);	// CAM_OUTPUT_FORMAT: Y-Cr-Y-Cb
	sccb_wr_r16d16(MT9M114_ID, 0xC984, 0x8040);	// CAM_PORT_OUTPUT_CONTROL
	sccb_wr_r16d16(MT9M114_ID, 0x001E, 0x0777);	// PAD_SLEW

#if (MT9M114_VGA)
	sccb_wr_r16d16(MT9M114_ID, 0x098E, 0x1000);	// LOGICAL_ADDRESS_ACCESS
	sccb_wr_r16d8(MT9M114_ID,  0xC97E, 0x01);	// CAM_SYSCTL_PLL_ENABLE
	sccb_wr_r16d16(MT9M114_ID, 0xC980, 0x0228);	// CAM_SYSCTL_PLL_DIVIDER_M_N
	sccb_wr_r16d16(MT9M114_ID, 0xC982, 0x0700);	// CAM_SYSCTL_PLL_DIVIDER_P
	sccb_wr_r16d16(MT9M114_ID, 0xC984, 0x8008);	// CAM_PORT_OUTPUT_CONTROL
	sccb_wr_r16d16(MT9M114_ID, 0xC800, 0x0004);	// CAM_SENSOR_CFG_Y_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xC802, 0x0004);	// CAM_SENSOR_CFG_X_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xC804, 0x03CB);	// CAM_SENSOR_CFG_Y_ADDR_END
	sccb_wr_r16d16(MT9M114_ID, 0xC806, 0x050B);	// CAM_SENSOR_CFG_X_ADDR_END
	sccb_wr_r16d32(MT9M114_ID, 0xC808, 0x02625A00);	// CAM_SENSOR_CFG_PIXCLK
	sccb_wr_r16d16(MT9M114_ID, 0xC80C, 0x0001);	// CAM_SENSOR_CFG_ROW_SPEED
	sccb_wr_r16d16(MT9M114_ID, 0xC80E, 0x00DB);	// CAM_SENSOR_CFG_FINE_INTEG_TIME_MIN
	sccb_wr_r16d16(MT9M114_ID, 0xC810, 0x05B9);	// CAM_SENSOR_CFG_FINE_INTEG_TIME_MAX
	sccb_wr_r16d16(MT9M114_ID, 0xC812, 0x03FF);	// CAM_SENSOR_CFG_FRAME_LENGTH_LINES
	sccb_wr_r16d16(MT9M114_ID, 0xC814, 0x063C);	// CAM_SENSOR_CFG_LINE_LENGTH_PCK
	sccb_wr_r16d16(MT9M114_ID, 0xC816, 0x0060);	// CAM_SENSOR_CFG_FINE_CORRECTION
	sccb_wr_r16d16(MT9M114_ID, 0xC818, 0x03C3);	// CAM_SENSOR_CFG_CPIPE_LAST_ROW
	sccb_wr_r16d16(MT9M114_ID, 0xC826, 0x0020);	// CAM_SENSOR_CFG_REG_0_DATA
	sccb_wr_r16d16(MT9M114_ID, 0xC834, 0x0000);	// CAM_SENSOR_CONTROL_READ_MODE
	sccb_wr_r16d16(MT9M114_ID, 0xC854, 0x0000);	// CAM_CROP_WINDOW_XOFFSET
	sccb_wr_r16d16(MT9M114_ID, 0xC856, 0x0000);	// CAM_CROP_WINDOW_YOFFSET
	sccb_wr_r16d16(MT9M114_ID, 0xC858, 0x0500);	// CAM_CROP_WINDOW_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xC85A, 0x03C0);	// CAM_CROP_WINDOW_HEIGHT
	sccb_wr_r16d8(MT9M114_ID,  0xC85C, 0x03);	// CAM_CROP_CROPMODE
	sccb_wr_r16d16(MT9M114_ID, 0xC868, 0x0280);	// CAM_OUTPUT_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xC86A, 0x01E0);	// CAM_OUTPUT_HEIGHT
	sccb_wr_r16d16(MT9M114_ID, 0xC88C, 0x1D9A);	// CAM_AET_MAX_FRAME_RATE
	sccb_wr_r16d16(MT9M114_ID, 0xC88E, 0x0F00);	// CAM_AET_MIN_FRAME_RATE
	sccb_wr_r16d16(MT9M114_ID, 0xC914, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC916, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC918, 0x027F);	// CAM_STAT_AWB_CLIP_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91A, 0x01DF);	// CAM_STAT_AWB_CLIP_WINDOW_YEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91C, 0x0000);	// CAM_STAT_AE_INITIAL_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC91E, 0x0000);	// CAM_STAT_AE_INITIAL_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC920, 0x007F);	// CAM_STAT_AE_INITIAL_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC922, 0x005F);	// CAM_STAT_AE_INITIAL_WINDOW_YEND
	sccb_wr_r16d16(MT9M114_ID, 0xE808, 0x0330);	// AUTO_BINNING_BIN_READ_MODE
	sccb_wr_r16d16(MT9M114_ID, 0xE80A, 0x0000);	// AUTO_BINNING_BIN_SENSOR_Y_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xE80C, 0x0000);	// AUTO_BINNING_BIN_SENSOR_X_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xE80E, 0x03CD);	// AUTO_BINNING_BIN_SENSOR_Y_ADDR_END
	sccb_wr_r16d16(MT9M114_ID, 0xE810, 0x050D);	// AUTO_BINNING_BIN_SENSOR_X_ADDR_END
	sccb_wr_r16d16(MT9M114_ID, 0xE812, 0x01C3);	// AUTO_BINNING_BIN_SENSOR_FINE_INTEG_TIME_MIN
	sccb_wr_r16d16(MT9M114_ID, 0xE814, 0x04B6);	// AUTO_BINNING_BIN_SENSOR_FINE_INTEG_TIME_MAX
	sccb_wr_r16d16(MT9M114_ID, 0xE816, 0x00E0);	// AUTO_BINNING_BIN_SENSOR_FINE_CORRECTION
	sccb_wr_r16d16(MT9M114_ID, 0xE818, 0x01E3);	// AUTO_BINNING_BIN_SENSOR_CPIPE_LAST_ROW
	sccb_wr_r16d16(MT9M114_ID, 0xE81A, 0x0280);	// AUTO_BINNING_BIN_CROP_WINDOW_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xE81C, 0x01E0);	// AUTO_BINNING_BIN_CROP_WINDOW_HEIGHT
#endif
#if (MT9M114_1024x768)
	sccb_wr_r16d16(MT9M114_ID, 0x098E, 0x1000);	// LOGICAL_ADDRESS_ACCESS
	sccb_wr_r16d8(MT9M114_ID,  0xC97E, 0x01);	// CAM_SYSCTL_PLL_ENABLE
	sccb_wr_r16d16(MT9M114_ID, 0xC980, 0x0228);	// CAM_SYSCTL_PLL_DIVIDER_M_N
	sccb_wr_r16d16(MT9M114_ID, 0xC982, 0x0700);	// CAM_SYSCTL_PLL_DIVIDER_P
	sccb_wr_r16d16(MT9M114_ID, 0xC984, 0x8008);	// CAM_PORT_OUTPUT_CONTROL
	sccb_wr_r16d16(MT9M114_ID, 0xC800, 0x0004);	// CAM_SENSOR_CFG_Y_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xC802, 0x0004);	// CAM_SENSOR_CFG_X_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xC804, 0x03CB);	// CAM_SENSOR_CFG_Y_ADDR_END
	sccb_wr_r16d16(MT9M114_ID, 0xC806, 0x050B);	// CAM_SENSOR_CFG_X_ADDR_END
	sccb_wr_r16d32(MT9M114_ID, 0xC808, 0x02625A00);	// CAM_SENSOR_CFG_PIXCLK
	sccb_wr_r16d16(MT9M114_ID, 0xC80C, 0x0001);	// CAM_SENSOR_CFG_ROW_SPEED
	sccb_wr_r16d16(MT9M114_ID, 0xC80E, 0x00DB);	// CAM_SENSOR_CFG_FINE_INTEG_TIME_MIN
	sccb_wr_r16d16(MT9M114_ID, 0xC810, 0x05B9);	// CAM_SENSOR_CFG_FINE_INTEG_TIME_MAX
	sccb_wr_r16d16(MT9M114_ID, 0xC812, 0x03FF);	// CAM_SENSOR_CFG_FRAME_LENGTH_LINES
	sccb_wr_r16d16(MT9M114_ID, 0xC814, 0x063C);	// CAM_SENSOR_CFG_LINE_LENGTH_PCK
	sccb_wr_r16d16(MT9M114_ID, 0xC816, 0x0060);	// CAM_SENSOR_CFG_FINE_CORRECTION
	sccb_wr_r16d16(MT9M114_ID, 0xC818, 0x03C3);	// CAM_SENSOR_CFG_CPIPE_LAST_ROW
	sccb_wr_r16d16(MT9M114_ID, 0xC826, 0x0020);	// CAM_SENSOR_CFG_REG_0_DATA
	sccb_wr_r16d16(MT9M114_ID, 0xC834, 0x0000);	// CAM_SENSOR_CONTROL_READ_MODE
	sccb_wr_r16d16(MT9M114_ID, 0xC854, 0x0000);	// CAM_CROP_WINDOW_XOFFSET
	sccb_wr_r16d16(MT9M114_ID, 0xC856, 0x0000);	// CAM_CROP_WINDOW_YOFFSET
	sccb_wr_r16d16(MT9M114_ID, 0xC858, 0x0500);	// CAM_CROP_WINDOW_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xC85A, 0x03C0);	// CAM_CROP_WINDOW_HEIGHT
	sccb_wr_r16d8(MT9M114_ID,  0xC85C, 0x03);	// CAM_CROP_CROPMODE
	sccb_wr_r16d16(MT9M114_ID, 0xC868, 0x0400);	// CAM_OUTPUT_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xC86A, 0x0300);	// CAM_OUTPUT_HEIGHT
	sccb_wr_r16d16(MT9M114_ID, 0xC88C, 0x1880);	// CAM_AET_MAX_FRAME_RATE
	sccb_wr_r16d16(MT9M114_ID, 0xC88E, 0x0F00);	// CAM_AET_MIN_FRAME_RATE
	sccb_wr_r16d16(MT9M114_ID, 0xC914, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC916, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC918, 0x03FF);	// CAM_STAT_AWB_CLIP_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91A, 0x02FF);	// CAM_STAT_AWB_CLIP_WINDOW_YEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91C, 0x0000);	// CAM_STAT_AE_INITIAL_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC91E, 0x0000);	// CAM_STAT_AE_INITIAL_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC920, 0x00CB);	// CAM_STAT_AE_INITIAL_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC922, 0x0098);	// CAM_STAT_AE_INITIAL_WINDOW_YEND
#endif
#if (MT9M114_1280x960)
	sccb_wr_r16d16(MT9M114_ID, 0x098E, 0x1000);	// LOGICAL_ADDRESS_ACCESS
	sccb_wr_r16d8(MT9M114_ID,  0xC97E, 0x01);	// CAM_SYSCTL_PLL_ENABLE
	sccb_wr_r16d16(MT9M114_ID, 0xC980, 0x0228);	// CAM_SYSCTL_PLL_DIVIDER_M_N
	sccb_wr_r16d16(MT9M114_ID, 0xC982, 0x0700);	// CAM_SYSCTL_PLL_DIVIDER_P
	sccb_wr_r16d16(MT9M114_ID, 0xC984, 0x8008);	// CAM_PORT_OUTPUT_CONTROL
	sccb_wr_r16d16(MT9M114_ID, 0xC800, 0x0004);	// CAM_SENSOR_CFG_Y_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xC802, 0x0004);	// CAM_SENSOR_CFG_X_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xC804, 0x03CB);	// CAM_SENSOR_CFG_Y_ADDR_END
	sccb_wr_r16d16(MT9M114_ID, 0xC806, 0x050B);	// CAM_SENSOR_CFG_X_ADDR_END
	sccb_wr_r16d32(MT9M114_ID, 0xC808, 0x02625A00);	// CAM_SENSOR_CFG_PIXCLK
	sccb_wr_r16d16(MT9M114_ID, 0xC80C, 0x0001);	// CAM_SENSOR_CFG_ROW_SPEED
	sccb_wr_r16d16(MT9M114_ID, 0xC80E, 0x00DB);	// CAM_SENSOR_CFG_FINE_INTEG_TIME_MIN
	sccb_wr_r16d16(MT9M114_ID, 0xC810, 0x05CF);	// CAM_SENSOR_CFG_FINE_INTEG_TIME_MAX
	sccb_wr_r16d16(MT9M114_ID, 0xC812, 0x03F1);	// CAM_SENSOR_CFG_FRAME_LENGTH_LINES
	sccb_wr_r16d16(MT9M114_ID, 0xC814, 0x0652);	// CAM_SENSOR_CFG_LINE_LENGTH_PCK
	sccb_wr_r16d16(MT9M114_ID, 0xC816, 0x0060);	// CAM_SENSOR_CFG_FINE_CORRECTION
	sccb_wr_r16d16(MT9M114_ID, 0xC818, 0x03C3);	// CAM_SENSOR_CFG_CPIPE_LAST_ROW
	sccb_wr_r16d16(MT9M114_ID, 0xC826, 0x0020);	// CAM_SENSOR_CFG_REG_0_DATA
	sccb_wr_r16d16(MT9M114_ID, 0xC834, 0x0000);	// CAM_SENSOR_CONTROL_READ_MODE
	sccb_wr_r16d16(MT9M114_ID, 0xC854, 0x0000);	// CAM_CROP_WINDOW_XOFFSET
	sccb_wr_r16d16(MT9M114_ID, 0xC856, 0x0000);	// CAM_CROP_WINDOW_YOFFSET
	sccb_wr_r16d16(MT9M114_ID, 0xC858, 0x0500);	// CAM_CROP_WINDOW_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xC85A, 0x03C0);	// CAM_CROP_WINDOW_HEIGHT
	sccb_wr_r16d8(MT9M114_ID,  0xC85C, 0x03);	// CAM_CROP_CROPMODE
	sccb_wr_r16d16(MT9M114_ID, 0xC868, 0x0500);	// CAM_OUTPUT_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xC86A, 0x03C0);	// CAM_OUTPUT_HEIGHT
	sccb_wr_r16d16(MT9M114_ID, 0xC88C, 0x1880);	// CAM_AET_MAX_FRAME_RATE
	sccb_wr_r16d16(MT9M114_ID, 0xC88E, 0x0F00);	// CAM_AET_MIN_FRAME_RATE
	sccb_wr_r16d16(MT9M114_ID, 0xC914, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC916, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC918, 0x04FF);	// CAM_STAT_AWB_CLIP_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91A, 0x03BF);	// CAM_STAT_AWB_CLIP_WINDOW_YEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91C, 0x0000);	// CAM_STAT_AE_INITIAL_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC91E, 0x0000);	// CAM_STAT_AE_INITIAL_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC920, 0x00FF);	// CAM_STAT_AE_INITIAL_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC922, 0x00BF);	// CAM_STAT_AE_INITIAL_WINDOW_YEND
#endif
#if (MT9M114_720P)
	sccb_wr_r16d16(MT9M114_ID, 0x098E, 0x1000);	// LOGICAL_ADDRESS_ACCESS
	sccb_wr_r16d8(MT9M114_ID,  0xC97E, 0x01);	// CAM_SYSCTL_PLL_ENABLE
	sccb_wr_r16d16(MT9M114_ID, 0xC980, 0x0228);	// CAM_SYSCTL_PLL_DIVIDER_M_N
	sccb_wr_r16d16(MT9M114_ID, 0xC982, 0x0700);	// CAM_SYSCTL_PLL_DIVIDER_P
	sccb_wr_r16d16(MT9M114_ID, 0xC984, 0x8008);	// CAM_PORT_OUTPUT_CONTROL
	sccb_wr_r16d16(MT9M114_ID, 0xC800, 0x0004);	// CAM_SENSOR_CFG_Y_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xC802, 0x0004);	// CAM_SENSOR_CFG_X_ADDR_START
	sccb_wr_r16d16(MT9M114_ID, 0xC804, 0x03CB);	// CAM_SENSOR_CFG_Y_ADDR_END
	sccb_wr_r16d16(MT9M114_ID, 0xC806, 0x050B);	// CAM_SENSOR_CFG_X_ADDR_END
	sccb_wr_r16d32(MT9M114_ID, 0xC808, 0x02625A00);	// CAM_SENSOR_CFG_PIXCLK
	sccb_wr_r16d16(MT9M114_ID, 0xC80C, 0x0001);	// CAM_SENSOR_CFG_ROW_SPEED
	sccb_wr_r16d16(MT9M114_ID, 0xC80E, 0x00DB);	// CAM_SENSOR_CFG_FINE_INTEG_TIME_MIN
	sccb_wr_r16d16(MT9M114_ID, 0xC810, 0x05CF);	// CAM_SENSOR_CFG_FINE_INTEG_TIME_MAX
	sccb_wr_r16d16(MT9M114_ID, 0xC812, 0x03F1);	// CAM_SENSOR_CFG_FRAME_LENGTH_LINES
	sccb_wr_r16d16(MT9M114_ID, 0xC814, 0x0652);	// CAM_SENSOR_CFG_LINE_LENGTH_PCK
	sccb_wr_r16d16(MT9M114_ID, 0xC816, 0x0060);	// CAM_SENSOR_CFG_FINE_CORRECTION
	sccb_wr_r16d16(MT9M114_ID, 0xC818, 0x03C3);	// CAM_SENSOR_CFG_CPIPE_LAST_ROW
	sccb_wr_r16d16(MT9M114_ID, 0xC826, 0x0020);	// CAM_SENSOR_CFG_REG_0_DATA
	sccb_wr_r16d16(MT9M114_ID, 0xC834, 0x0000);	// CAM_SENSOR_CONTROL_READ_MODE
	sccb_wr_r16d16(MT9M114_ID, 0xC854, 0x0000);	// CAM_CROP_WINDOW_XOFFSET
	sccb_wr_r16d16(MT9M114_ID, 0xC856, 0x0000);	// CAM_CROP_WINDOW_YOFFSET
	sccb_wr_r16d16(MT9M114_ID, 0xC858, 0x0500);	// CAM_CROP_WINDOW_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xC85A, 0x03C0);	// CAM_CROP_WINDOW_HEIGHT
	sccb_wr_r16d8(MT9M114_ID,  0xC85C, 0x03);	// CAM_CROP_CROPMODE
	sccb_wr_r16d16(MT9M114_ID, 0xC868, 0x0500);	// CAM_OUTPUT_WIDTH
	sccb_wr_r16d16(MT9M114_ID, 0xC86A, 0x02D0);	// CAM_OUTPUT_HEIGHT
	sccb_wr_r16d16(MT9M114_ID, 0xC88C, 0x1880);	// CAM_AET_MAX_FRAME_RATE
	sccb_wr_r16d16(MT9M114_ID, 0xC88E, 0x0F00);	// CAM_AET_MIN_FRAME_RATE
	sccb_wr_r16d16(MT9M114_ID, 0xC914, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC916, 0x0000);	// CAM_STAT_AWB_CLIP_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC918, 0x04FF);	// CAM_STAT_AWB_CLIP_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91A, 0x02CF);	// CAM_STAT_AWB_CLIP_WINDOW_YEND
	sccb_wr_r16d16(MT9M114_ID, 0xC91C, 0x0000);	// CAM_STAT_AE_INITIAL_WINDOW_XSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC91E, 0x0000);	// CAM_STAT_AE_INITIAL_WINDOW_YSTART
	sccb_wr_r16d16(MT9M114_ID, 0xC920, 0x00FF);	// CAM_STAT_AE_INITIAL_WINDOW_XEND
	sccb_wr_r16d16(MT9M114_ID, 0xC922, 0x008F);	// CAM_STAT_AE_INITIAL_WINDOW_YEND
#endif

	sccb_wr_r16d8(MT9M114_ID, 0xDC00, 0x28);	// sysmgr_next_state
	mt9m114_host_command_x(0x8002);

	drv_msec_wait(50);


	R_CSI_TG_CTRL1 = uCtrlReg2;			//*P_Sensor_TG_Ctrl2 = uCtrlReg2;
#if CSI_IRQ_MODE == CSI_IRQ_PPU_IRQ
	R_CSI_TG_CTRL0 = uCtrlReg1;			//*P_Sensor_TG_Ctrl1 = uCtrlReg1;
#elif CSI_IRQ_MODE == CSI_IRQ_TG_IRQ
	R_CSI_TG_CTRL0 = uCtrlReg1 | (1 << 16);
#elif CSI_IRQ_MODE == CSI_IRQ_TG_FIFO8_IRQ
	R_CSI_TG_CTRL0 = uCtrlReg1 | (1 << 20) | (1 << 16);
#elif CSI_IRQ_MODE == CSI_IRQ_TG_FIFO16_IRQ
	R_CSI_TG_CTRL0 = uCtrlReg1 | (2 << 20) | (1 << 16);
#elif CSI_IRQ_MODE == CSI_IRQ_TG_FIFO32_IRQ
	R_CSI_TG_CTRL0 = uCtrlReg1 | (3 << 20) | (1 << 16);
#endif
	_D(DBG_PRINT(" nWidthH=%04d, nWidthV=%04d, uFlag=0x%04x\r\n", nWidthH, nWidthV, uFlag));
	_D(DBG_PRINT(" R_CSI_TG_HRATIO  = 0x%04x, R_CSI_TG_HWIDTH  = %04d\r\n", (INT16U) R_CSI_TG_HRATIO, (INT16U) R_CSI_TG_HWIDTH));
	_D(DBG_PRINT(" R_CSI_TG_VRATIO  = 0x%04x, R_CSI_TG_VHEIGHT = %04d\r\n", (INT16U) R_CSI_TG_VRATIO, (INT16U) R_CSI_TG_VHEIGHT));
	_D(DBG_PRINT(" R_CSI_TG_CTRL0   = 0x%04x\r\n", (INT16U) uCtrlReg1));
	_D(DBG_PRINT(" R_CSI_TG_CTRL1   = 0x%04x\r\n", (INT16U) uCtrlReg2));
	_D(DBG_PRINT("\033[1;36mMT9M114 - done\r\n\033[0m"));
}

/*
 *****************************************************************************
 * Eod Of File
 *****************************************************************************
 */
#endif	/* __MT9M114_DRV_C__ */
#endif	/* (defined _DRV_L1_SENSOR) && (_DRV_L1_SENSOR == 1) */
